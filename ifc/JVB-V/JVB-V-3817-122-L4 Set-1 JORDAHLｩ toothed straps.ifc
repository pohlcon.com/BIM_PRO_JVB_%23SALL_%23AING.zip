Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2018-03-22T15:59:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 22 15:59:01 2018 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{73BC151D-8925-4425-AC9C-10AA25DDDF6D}\ifc * Database version: 5507 * Database creation date: Thu Mar 22 15:59:00 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 22 15:59:00 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 22 15:59:00 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 1 m

# IfcFastener: JTA-W L=300 mm, JTA-K JORDAHL® AnchorChannels:JTA-W L=300 mm:436918
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH

# IfcFastener: JVB-V-3817-122, JVB-V JORDAHL® toothed straps set:JVB-V-3817-122:436938
In: Ebene 0
Type - Material: Stahl, Edelstahl, Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH
