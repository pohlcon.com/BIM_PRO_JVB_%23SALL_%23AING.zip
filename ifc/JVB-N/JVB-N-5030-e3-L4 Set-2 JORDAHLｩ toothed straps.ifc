Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2018-03-22T16:05:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 22 16:05:52 2018 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{03A1084A-EBC4-4105-86AE-0B78AE84AA3D}\ifc * Database version: 5507 * Database creation date: Thu Mar 22 16:05:51 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 22 16:05:51 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 22 16:05:51 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 1 m

# IfcFastener: JTA-W L=150 mm, JTA-K JORDAHL® AnchorChannels:JTA-W L=150 mm:418321
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH

# IfcFastener: JVB-N-5030, JVB-N JORDAHL® toothed straps set:JVB-N-5030:418317
In: Ebene 0
Type - Material: Stahl, Edelstahl, Steel
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL® GmbH
